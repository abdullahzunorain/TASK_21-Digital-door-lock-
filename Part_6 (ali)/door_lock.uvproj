# Keil uVision project door_lock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: door_lock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: task_21.c main.c BUZZER.c BUZZER.h KEY_PAD.c KEY_PAD.h KEYPAD.c KEYPAD.h SERVO_MOTOR.c SERVO_MOTOR.h LCD.c LCD.h EEPTOM.c EEPROM.c EEPROM.h
